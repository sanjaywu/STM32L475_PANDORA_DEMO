# Keil uVision project STM32L475_PANDORA_DEMO.uvprojx, settings and files
target STM32L475_PANDORA_DEMO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L475_PANDORA_DEMO
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: .\Inc;..\HALLIB\Inc;..\HALLIB\Inc\Legacy;..\CMSIS;..\SYSTEM;..\USMART;..\HARDWARE\led;..\HARDWARE\key;..\HARDWARE\exit;..\HARDWARE\wdg;..\HARDWARE\timer;..\HARDWARE\pwm;..\HARDWARE\lcd;..\HARDWARE\rtc;..\HARDWARE\wkup;..\HARDWARE\low_power;..\HARDWARE\aht10;..\HARDWARE\w25qxx
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group USER
    ./Src/: main.c stm32l4xx_it.c system_stm32l4xx.c
  group CMSIS
    ../CMSIS/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l475xx.s
  group HALLIB
    ../HALLIB/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_qspi.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/exit/: exti.c
    ../HARDWARE/wdg/: iwdg.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/pwm/: pwm.c
    ../HARDWARE/lcd/: lcd.c font.c
    ../HARDWARE/rtc/: rtc.c
    ../HARDWARE/wkup/: wkup.c
    ../HARDWARE/low_power/: low_power.c
    ../HARDWARE/aht10/: aht10.c i2c.c
    ../HARDWARE/w25qxx/: w25qxx.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
